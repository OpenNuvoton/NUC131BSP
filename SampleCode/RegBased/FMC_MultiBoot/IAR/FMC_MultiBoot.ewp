# IAR project FMC_MultiBoot.ewp, settings and files
configuration FMC_MultiBoot (ARM)
  General.OGChipSelectEditMenu: NUC131AE series Nuvoton NUC131AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\NUC131\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: FMC_MultiBoot.bin
  ILINK.IlinkOutputFile: FMC_MultiBoot.out
  ILINK.IlinkIcfFile: FMC_MultiBoot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FMC_Boot0 (ARM)
  as the first configuration, except:
configuration FMC_Boot1 (ARM)
  as the first configuration, except:
configuration FMC_Boot2 (ARM)
  as the first configuration, except:
configuration FMC_Boot3 (ARM)
  as the first configuration, except:
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC131/Source/IAR/: startup_NUC131.s
    ../../../../Library/Device/Nuvoton/NUC131/Source/: system_NUC131.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c
  group User
    ../: main.c
